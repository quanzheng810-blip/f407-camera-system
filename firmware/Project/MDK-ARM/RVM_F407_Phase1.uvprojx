# Keil uVision project RVM_F407_Phase1.uvprojx, settings and files
target RVM_F407_Phase1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RVM_F407_Phase1 +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,RVM_BOARD_BATIANHU_V2,RVM_LCD_ILI9806G
  c include: ..\..\Platform\CMSIS\Include;..\..\Platform\CMSIS\Device\ST\STM32F4xx\Include;..\..\Platform\STM32F4xx_StdPeriph_Driver\inc;..\..\Core\Inc;..\..\Board;..\..\Drivers;..\..\Drivers\camera;..\..\Drivers\lcd;..\..\Drivers\key;..\..\Drivers\led;..\..\Drivers\sram;..\..\Drivers\systick;..\..\Drivers\usart;..\..\Components;..\..\Components\buffer_pool\include;..\..\Components\font;..\..\Components\logging\include;..\..\Components\metrics\include;..\..\Components\timebase\include;..\..\Services\camera\include;..\..\Services\display\include;..\..\Services\network\include;..\..\Services\system\include;..\..\App\include;..\..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group 00_PLATFORM
    ../../Platform/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
    ../../Platform/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../Platform/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group 01_BSP
    ../../Core/Src/: rvm_interrupts.c
    ../../Board/: board_init.c board_config.h
    ../../Drivers/camera/: bsp_ov5640.c ov5640_AF.c camera_driver.c
    ../../Drivers/lcd/: bsp_ili9806g_lcd.c display_driver.c
    ../../Drivers/usart/: bsp_debug_usart.c
    ../../Drivers/systick/: bsp_SysTick.c
    ../../Drivers/key/: bsp_key.c
  group 02_COMMON
    ../../Components/font/: fonts.c
    ../../Components/timebase/src/: rvm_timebase.c
    ../../Components/logging/src/: rvm_log.c
    ../../Components/metrics/src/: rvm_metrics.c
  group 03_SERVICES
    ../../Services/camera/src/: camera_service.c
    ../../Services/display/src/: display_service.c
    ../../Services/system/src/: system_service.c
  group 04_APP
    ../../App/src/: app_main.c main.c
  group 05_DOC
    ../../: README.md
