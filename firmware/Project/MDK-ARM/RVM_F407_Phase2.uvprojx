# Keil uVision project RVM_F407_Phase2.uvprojx, settings and files
target RVM_F407_Phase2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RVM_F407_Phase2 +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,RVM_BOARD_BATIANHU_V2,RVM_LCD_ILI9806G,LV_CONF_INCLUDE_SIMPLE
  c misc: --diag_suppress=1,68,111,128,188,546
  c include: ..\..\Platform\CMSIS\Include;..\..\Platform\CMSIS\Device\ST\STM32F4xx\Include;..\..\Platform\STM32F4xx_StdPeriph_Driver\inc;..\..\Core\Inc;..\..\Board;..\..\Drivers;..\..\Drivers\camera;..\..\Drivers\lcd;..\..\Drivers\key;..\..\Drivers\led;..\..\Drivers\sram;..\..\Drivers\systick;..\..\Drivers\usart;..\..\Components;..\..\Components\buffer_pool\include;..\..\Components\serial_protocol\include;..\..\Components\font;..\..\Components\logging\include;..\..\Components\metrics\include;..\..\Components\timebase\include;..\..\Services\camera\include;..\..\Services\display\include;..\..\Services\network\include;..\..\Services\serial_image\include;..\..\Services\system\include;..\..\App\include;..\..\Config;..\..\Middleware\FreeRTOS\Source\include;..\..\Middleware\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Middleware\LVGL;..\..\Middleware\LVGL\src;..\..\Middleware\LVGL\port;..\..\Services\ui\include;..\..\Drivers\ethernet;..\..\Drivers\ethernet\legacy\inc;..\..\Middleware\lwIP\include;..\..\Middleware\lwIP\port;..\..\Middleware\lwIP\port\arch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group 00_PLATFORM
    ../../Platform/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
    ../../Platform/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../Platform/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group 01_BSP
    ../../Core/Src/: rvm_interrupts.c
    ../../Board/: board_init.c board_config.h
    ../../Drivers/camera/: bsp_ov5640.c ov5640_AF.c camera_driver.c dcmi_framebuffer.c
    ../../Drivers/lcd/: bsp_ili9806g_lcd.c display_driver.c
    ../../Drivers/usart/: bsp_debug_usart_dma.c
    ../../Drivers/systick/: bsp_SysTick.c
    ../../Drivers/key/: bsp_key.c
    ../../Drivers/ethernet/: bsp_eth.c
    ../../Drivers/ethernet/legacy/src/: stm32f4x7_eth.c
    ../../Drivers/sram/: bsp_sram.c
  group 02_MIDDLEWARE_FREERTOS
    ../../Middleware/FreeRTOS/Source/: tasks.c queue.c list.c timers.c event_groups.c
    ../../Middleware/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../Middleware/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group 02_MIDDLEWARE_LWIP
    ../../Middleware/lwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Middleware/lwIP/core/: altcp_alloc.c altcp_tcp.c altcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp_in.c tcp_out.c tcp.c timeouts.c udp.c
    ../../Middleware/lwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4_addr.c ip4_frag.c ip4.c
    ../../Middleware/lwIP/netif/: ethernet.c
    ../../Middleware/lwIP/port/: ethernetif.c sys_arch.c
  group 02_MIDDLEWARE_LVGL
    ../../Middleware/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev_scroll.c lv_indev.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style_gen.c lv_obj_style.c lv_obj_tree.c lv_obj.c lv_refr.c lv_theme.c
    ../../Middleware/LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../Middleware/LVGL/src/draw/: lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_draw.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../Middleware/LVGL/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_draw_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c
    ../../Middleware/LVGL/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_draw_vglite.c lv_vglite_buf.c lv_vglite_utils.c
    ../../Middleware/LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../../Middleware/LVGL/src/draw/sdl/: lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c lv_draw_sdl.c
    ../../Middleware/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../Middleware/LVGL/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c lv_draw_sw.c
    ../../Middleware/LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../../Middleware/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../../Middleware/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../../Middleware/LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../../Middleware/LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../Middleware/LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../../Middleware/LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../Middleware/LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../Middleware/LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../../Middleware/LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../Middleware/LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../../Middleware/LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../Middleware/LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../Middleware/LVGL/src/extra/: lv_extra.c
    ../../Middleware/LVGL/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    ../../Middleware/LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../../Middleware/LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../../Middleware/LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../../Middleware/LVGL/src/extra/others/monkey/: lv_monkey.c
    ../../Middleware/LVGL/src/extra/others/msg/: lv_msg.c
    ../../Middleware/LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../../Middleware/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../../Middleware/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../../Middleware/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../../Middleware/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../../Middleware/LVGL/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    ../../Middleware/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../../Middleware/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../Middleware/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../Middleware/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../Middleware/LVGL/src/extra/widgets/led/: lv_led.c
    ../../Middleware/LVGL/src/extra/widgets/list/: lv_list.c
    ../../Middleware/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../../Middleware/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../../Middleware/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../Middleware/LVGL/src/extra/widgets/span/: lv_span.c
    ../../Middleware/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../Middleware/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../../Middleware/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../../Middleware/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../../Middleware/LVGL/src/extra/widgets/win/: lv_win.c
    ../../Middleware/LVGL/src/font/: lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12_subpx.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28_compressed.c lv_font_montserrat_28.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_font.c
    ../../Middleware/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../Middleware/LVGL/src/misc/: lv_anim_timeline.c lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style_gen.c lv_style.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt_ap.c lv_txt.c lv_utils.c
    ../../Middleware/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../Middleware/LVGL/port/: lv_port_disp.c
  group 02_COMMON
    ../../Components/font/: fonts.c
    ../../Components/timebase/src/: rvm_timebase.c
    ../../Components/logging/src/: rvm_log.c
    ../../Components/metrics/src/: rvm_metrics.c
    ../../Components/buffer_pool/src/: video_buffer.c
    ../../Components/serial_protocol/src/: serial_protocol.c
  group 03_SERVICES
    ../../Services/camera/src/: camera_service.c
    ../../Services/display/src/: display_service.c
    ../../Services/system/src/: system_service.c
    ../../Services/ui/src/: ui_service.c
    ../../Services/network/src/: network_service.c
    ../../Services/serial_image/src/: serial_image_service.c
  group 04_APP
    ../../App/src/: app_main.c main.c app_tasks.c
  group 05_DOC
    ../../: README.md
